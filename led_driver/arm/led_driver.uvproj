# Keil uVision project led_driver.uvproj, settings and files
target nrf51822_xxaa_s110 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51822_xxaa_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 SOFTDEVICE_PRESENT BLE_STACK_SUPPORT_REQD BOARD_PCA10000
  c misc: --c99
  c include: ..\..\..\..\..\Include;.\..;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\sdk;..\..\..\..\..\Include\sd_common
  asm define: as above
  library: MicroLIB
  scatter file: ..\..\..\..\..\..\..\framework\helper_scripts\genproject\toolchains\arm\nrf51822_xxaa_s110.sct
  group Startup
    ../../../../../Source/templates/: system_nrf51.c
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
  group app
    ./../: main.c
  group lib
    ../: led.c lss.c
    ../../../../../Source/ble/: ble_advdata.c ble_conn_params.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
    ../../../../../Source/app_common/: pstorage.c app_trace.c app_timer.c app_gpiote.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s110 (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51822_xxab_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: as above
  c misc: --c99
  c include: as above
  asm define: as above
  library: MicroLIB
  scatter file: ..\..\..\..\..\..\..\framework\helper_scripts\genproject\toolchains\arm\nrf51822_xxab_s110.sct
