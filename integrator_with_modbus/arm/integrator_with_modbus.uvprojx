# Keil uVision project integrator_with_modbus.uvprojx, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_c +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001 ENABLE_DEBUG_LOG_SUPPORT
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s120;..\..\..\..\..\include\boards;..\..\..\..\..\include\sd_common;..\..\common;..\..\..\..\Include\ext_sensors;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
    ../: devices.c modbus.c
  group Libraries
    ../../../../../Source/app_common/: app_trace.c pstorage.c app_button.c app_gpiote.c app_timer.c app_scheduler.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/ble/device_manager/experimental/: device_manager_central.c
    ../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: ble_app_hrs_c +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s120;..\..\..\..\..\..\include\boards;..\..\..\..\..\..\include\sd_common;..\..\..\experimental;..\..\common;..\..\..\..\..\..\Include\ext_sensors;..\..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
